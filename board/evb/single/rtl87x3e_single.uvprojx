# Keil uVision project rtl87x3e_single.uvprojx, settings and files
target single_2M_lea_dual_bank0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: single
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 2M rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_2M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8763EKH=1 HARMAN_T530_SUPPORT = 1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude ble_audio_flags.h --preinclude app_flags.h --preinclude app_lea_flags.h  --feedback .\target\rtl87x3e\fout.txt
  c include: .\inc\rtl87x3e_efl;..\single;..\..\..\inc\app;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\stack;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\platform\console;..\..\..\inc\framework;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\mmi;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\rtl87x3e\hal;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\leaudio;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\service;..\..\..\inc\service\gfps;..\..\..\inc\service\bisto;..\..\..\inc\service\xiaoai;..\..\..\inc\service\xiaowei;..\..\..\inc\service\ama;..\..\..\inc\service\teams;..\..\..\inc\service\teams\asp_device;..\..\..\inc\service\teams\hid;..\..\..\inc\service\teams\ble;..\..\..\src\mcu\module\led;..\..\..\inc\hal\power;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\mcu\rtl876x;..\..\..\src\mcu\module\vector;..\..\..\src\mcu\module\stream;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\ble\gatt_client;..\..\..\src\debug;..\..\..\src\sample\rws;..\..\..\src\sample\rws\local_playback;..\..\..\src\sample\rws\local_playback\sd_emmc;..\..\..\src\sample\rws\bqb;..\..\..\src\sample\rws\console;..\..\..\src\sample\rws\cli;..\..\..\src\sample\rws\bud;..\..\..\src\sample\rws\mp;..\..\..\src\sample\rws\app;..\..\..\src\sample\rws\engage;..\..\..\src\sample\rws\gfps;..\..\..\src\sample\rws\xiaoai;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\ama;..\..\..\src\sample\rws\eq;..\..\..\src\sample\rws\dongle;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\asp_device;..\..\..\src\sample\rws\teams\hid;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\cfu;..\..\..\src\sample\rws\teams\cfu\Signature;..\..\..\src\sample\rws\xiaowei;..\..\..\src\sample\rws\lea;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\src\sample\rws\teams\cfu\Signature;..\..\..\inc\ble_mgr;..\..\..\src\sample\rws\bond;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_app;..\..\..\src\sample\rws\tuya\tuya_enc\mbedtls;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_port;..\..\..\src\sample\rws\tuya\tuya_ble_sdk;..\..\..\src\sample\rws\tuya\tuya_enc;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\io;..\..\..\inc\ble_mgr\bond;..\..\..\src\mcu\module\console\transport;..\..\..\src\sample\rws\ha;..\..\..\inc\hal\platform;..\..\..\src\sample\rws\usb;..\..\..\src\sample\rws\usb\audio;..\..\..\src\sample\rws\usb\hid;..\..\..\src\sample\rws\speaker;..\..\..\src\sample\common;..\..\..\inc\rtl87x3e\hal\stack;..\..\..\src\ble\bt_gatt_svc;..\..\..\src\sample\rws\harman;..\..\..\inc\usb;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\src\sample\rws\multitopology;..\..\..\src\sample\rws\ext_charger;..\..\..\src\sample\rws\harman_battery_verification;..\..\..\src\ble\bt_gatt_client
  asm misc: --cpreproc
  asm include: .\inc\rtl87x3e_efl
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3e\rtl87x3e_single_efl_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off --feedback .\target\rtl87x3e\fout.txt
  group include
    ./: config.h
    ../../../src/sample/rws/: app_flags.h
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3e/: ROM.lib framework.lib hal_utils.lib ble_mgr.lib leaudio.lib gfps.lib dual_audio_effect.lib gap_utils.lib usb_hal.lib usb.lib upperstack.lib battery verification.lib
    ../../../bin/rtl87x3e/framework/: sysm.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group module
    ../../../src/mcu/module/led/: led_module.c
    ../../../src/mcu/module/stream/: ble_stream.c iap_stream.c spp_stream.c common_stream.c
    ../../../src/mcu/module/vector/: vector.c
    ../../../src/sample/rws/: image_header.c
  group cli
    ../../../src/sample/rws/cli/: cli_cfg_cmd.c cli_cfg_main.c cli_power_cmd.c
  group bqb
    ../../../src/sample/rws/bqb/: bqb_main.c bqb_cmd.c
  group ble
    ../../../src/ble/profile/client/: ancs_client.c ams_client.c
    ../../../src/ble/profile/server/: transmit_service.c ota_service.c bas.c dis.c
    ../../../src/ble/gatt_client/: gattc_tbl_storage.c bt_ext_ftl.c
    ../../../src/ble/bt_gatt_svc/: transmit_svc_dongle.c
    ../../../src/ble/bt_gatt_client/: gaps_gatt_client.c
  group app
    ../../../src/sample/rws/: app_main.c app_util.c app_cfg.c app_io_msg.c app_led.c app_key_gpio.c app_key_process.c app_charger.c app_transfer.c app_report.c app_gap.c app_ble_gap.c app_ble_device.c app_ble_client.c app_ble_service.c app_ble_common_adv.c app_sdp.c app_hfp.c app_avrcp.c app_a2dp.c app_pbap.c app_iap.c app_roleswap.c app_relay.c app_device.c app_mmi.c app_link_util.c app_dlps.c app_linkback.c app_multilink.c app_bt_policy.c app_audio_policy.c app_gpio_on_off.c app_rdtp.c app_test.c app_anc.c app_eq.c app_nfc.c app_sensor_i2c.c app_sensor.c app_ota.c app_bt_policy_api.c app_in_out_box.c app_vad.c app_iap_rtk.c app_buzeer.c app_bond.c app_third_party_srv.c app_bt_sniffing.c app_audio_passthrough.c app_adp.c app_io_output.c app_console_msg.c app_cap_touch.c app_spp.c app_cmd.c app_listening_mode.c app_sensor_px318j.c app_auto_power_off.c app_line_in.c app_airplane.c app_adc.c app_ble_swift_pair.c app_audio_route.c app_hid.c app_qol.c app_ota_tooling.c app_hearable.c app_slide_switch.c app_sniff_mode.c app_iphone_abs_vol_handle.c app_ble_bond.c app_sensor_jsa.c rtk_charger.c app_audio_passthrough_brightness.c app_one_wire_uart.c app_bud_loc.c app_single_multilink_customer.c app_hfp_ag.c app_rtk_fast_pair_adv.c app_ble_rand_addr_mgr.c app_roleswap_control.c app_amp.c app_ipc.c app_adp_cmd.c app_adp_cmd_parse.c app_sensor_mems.c app_loc_mgr.c app_tts.c app_ble_sc_key_derive.c app_console.c app_spp_capture_dsp_data.c app_qdec.c app_ble_whitelist.c app_vendor.c app_usb_suspend.c app_bt_point.c
    ../../../src/sample/common/: app_dsp_cfg.c app_data_capture.c app_sidetone.c app_cfu_transfer.c app_common_cfu.c app_nrec.c
    ../../../src/sample/rws/eq/: eq_utils.c eq_ext_ftl.c app_eq_fitting.c
    ../../../src/sample/rws/usb/: app_usb.c
    ../../../src/sample/rws/usb/audio/: app_usb_audio.c
    ../../../src/sample/rws/usb/hid/: app_usb_mmi.c app_usb_hid_cmd.c
    ../../../src/sample/rws/dongle/: app_dongle_dual_mode.c app_dongle_ctrl.c
    ../../../src/sample/rws/ha/: ha_ext_ftl.c
    ../../../src/sample/rws/speaker/: app_multilink_customer.c
    ../../../src/sample/rws/ext_charger/: app_ext_charger.c
  group mp
    ../../../src/sample/rws/mp/: cli_mp_main.c mp_test.c mp_test_vendor.c single_tone.c
  group gfps
    ../../../src/sample/rws/gfps/: app_gfps.c app_gfps_account_key.c app_gfps_device.c app_gfps_personalized_name.c app_gfps_rfc.c app_ecc.c app_gfps_battery.c app_gfps_sync.c app_gfps_finder.c app_gfps_finder_adv.c app_gfps_link.c app_gfps_msg.c app_gfps_psm.c app_gfps_timer.c app_dult.c app_dult_device.c app_dult_svc.c
    ../../../src/sample/rws/: app_sass_policy.c
  group lea
    ../../../src/sample/rws/lea/: app_lea_adv.c app_lea_ascs.c app_lea_ccp.c app_lea_csis.c app_lea_mcp.c app_lea_pacs.c app_lea_scan.c app_lea_vcs.c app_lea_mgr.c app_lea_profile.c cli_le_audio.c app_lea_unicast_audio.c app_lea_realcast.c app_lea_vol_policy.c app_lea_broadcast_audio.c
  group bond
    ../../../src/sample/rws/bond/: ble_audio_bond.c ble_bond_sync.c
  group usb
    ../../../src/sample/rws/usb/audio/: usb_audio_stream.c usb_audio1.c
    ../../../src/sample/rws/usb/hid/: usb_hid.c
    ../../../src/sample/rws/usb/: usb_dev.c
  group mtc
    ../../../src/sample/rws/multitopology/: multitopology_ctrl.c
  group harman
    ../../../src/sample/rws/harman/: app_harman_behaviors.c app_harman_behaviors.h app_harman_ble.c app_harman_ble.h app_harman_ble_ota.c app_harman_parser.c app_harman_parser.h app_harman_report.c app_harman_report.h app_harman_vendor_cmd.c app_harman_vendor_cmd.h app_harman_license.c app_harman_eq.c app_harman_adc.c app_harman_usb_connector_protect.c
  group harman_battery_verify
    ../../../src/sample/rws/harman_battery_verification/: Battery_Verify_Control.c
